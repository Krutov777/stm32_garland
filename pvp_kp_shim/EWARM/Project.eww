<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\pvp_kp_shim.ewp</path>
  </project>
  <batchBuild />
</workspace>
